# Keil uVision project main.uvproj, settings and files
target flash (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: FD814 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src;..\inc;.\src
  group fd_chip_ctrl
    ./src/: AppUsart.c I2C.c
  group main
    ./: main.c
  group src
    ../src/: mydelay.c
    ./: TouchKey.C
target debug (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: FD_CHIP_CTRL +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: _DEBUG
  c include: ..\src;..\inc;.\src
