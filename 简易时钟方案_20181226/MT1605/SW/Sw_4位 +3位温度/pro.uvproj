# Keil uVision project pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x58RD SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x7FFF) CLOCK(40000000)
  output: pro +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\StdDriver\inc;.\App
  group setup
    ./: STARTUP.A51
  group library
    ./App/: FD612Drv.C config.c ds1302.c
    ./StdDriver/src/: Debug.C
  group usr
    ./App/: Main.C usr.c
