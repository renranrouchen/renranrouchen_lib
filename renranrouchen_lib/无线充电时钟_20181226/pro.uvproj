# Keil uVision project pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: pro +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver\inc;.\APP\include
  group setup
    ./: STARTUP.A51
  group driver
    ./driver/src/: uart.c delay.c
    ./APP/stdriver/: config.c ds1302.c FD612Drv_double.C FD612Drv_demo.c FD616.C
  group usr
    ./APP/: main.c
    ./APP/stdriver/: usr.c
