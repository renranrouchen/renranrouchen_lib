# Keil uVision project RTOSDemo.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: M453VG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.9
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: RTOSDemo +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c define: RVDS_ARMCM4_NUC4xx
  c misc: --c99
  c include: ..\Library\CMSIS\Include;..\Library\StdDriver\inc;..\Library\Device\Nuvoton\M451Series\Include;..\ThirdParty\FreeRTOS\SOURCE\include;..\ThirdParty\FreeRTOS\DEMO\COMMON\include;..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\..\XQD_RTOS;..\usr_file
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group System
    ../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group Demo Files
    ../: main.c
    ../usr_file/: config.c ST7567.C ST7567_API.C Event_process.c Get_event.c DMX512.C DMX512_API.C
  group FreeRTOS files
    ../ThirdParty/FreeRTOS/SOURCE/: tasks.c timers.c list.c queue.c
    ../ThirdParty/FreeRTOS/SOURCE/portable/RVDS/ARM_CM4F/: port.c
    ../ThirdParty/FreeRTOS/SOURCE/portable/MemMang/: heap_2.c
  group lib
    ../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c gpio.c fmc.c
